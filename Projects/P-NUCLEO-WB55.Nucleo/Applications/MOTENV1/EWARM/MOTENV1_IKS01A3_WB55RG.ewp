# IAR project MOTENV1_IKS01A3_WB55RG.ewp, settings and files
configuration MOTENV1_IKS01A3_WB55RG (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_IKS01A3; USE_HAL_DRIVER; STM32WB55xx; USE_LOGGER; ST25R3916; NFC_ENABLE
  ICCARM.CCIncludePath2: ../Core/Inc; ../STM32_WPAN/App; ../MEMS/App; ../MEMS/Target; ../../../../../Drivers/STM32WBxx_HAL_Driver/Inc; ../../../../../Utilities/lpm/tiny_lpm; ../tiny_lpm; ../../../../../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../../../../../Middlewares/ST/STM32_WPAN; ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread; ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl; ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci; ../../../../../Middlewares/ST/STM32_WPAN/utilities; ../../../../../Middlewares/ST/STM32_WPAN/ble/core; ../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto; ../../../../../Middlewares/ST/STM32_WPAN/ble/core/template; ../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Inc; ../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src; ../../../../../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../../../../../Utilities/sequencer; ../../../../../Middlewares/ST/STM32_WPAN/ble; ../../../../../Drivers/CMSIS/Include; ../../../../../Drivers/BSP/Components/lsm6dso/; ../../../../../Drivers/BSP/Components/lis2dw12/; ../../../../../Drivers/BSP/Components/lis2mdl/; ../../../../../Drivers/BSP/Components/hts221/; ../../../../../Drivers/BSP/Components/lps22hh/; ../../../../../Drivers/BSP/Components/stts751/; ../../../../../Drivers/BSP/IKS01A3/; ../../../../../Drivers/BSP/Components/Common/; ../../../../../Middlewares/ST/STM32_MotionFX_Library/Inc; ../../../../../Middlewares/ST/STM32_MotionAR_Library/Inc; ../../../../../Middlewares/ST/STM32_MotionAW_Library/Inc; ../../../../../Middlewares/ST/STM32_MotionCP_Library/Inc; ../../../../../Middlewares/ST/STM32_MotionGR_Library/Inc; ../../../../../Middlewares/ST/STM32_MotionPM_Library/Inc; ../../../../../Middlewares/ST/STM32_MotionID_Library/Inc; ../../../../../Drivers/BSP/common/Firmware/STM/utils/inc; ../../../../../Drivers/BSP/common/Firmware/STM/STM32/Inc; ../../../../../Drivers/BSP/Firmware/STM/STM32/src; ../../../../../Middlewares/ST/rfal/source/st25r3916; ../../../../../Middlewares/ST/rfal/include; ../../../../../Middlewares/ST/rfal/source; ../../../../../Middlewares/ST/ndef/include/poller; ../../../../../Middlewares/ST/ndef/include/message
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MOTENV1_IKS01A3_WB55RG.bin
  ILINK.IlinkOutputFile: MOTENV1_IKS01A3_WB55RG.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: app_entry.c hw_timerserver.c hw_uart.c main.c stm32_lpm_if.c stm32wbxx_hal_msp.c stm32wbxx_it.c stm32wbxx_nucleo_bus.c
  group Application/User/MEMS/App
    ../MEMS/App/: app_x-cube-mems1.c
  group Application/User/STM32_WPAN/App
    ../STM32_WPAN/App/: app_ble.c config_server_app.c console_server_app.c env_server_app.c motenv_server_app.c motion_ext_server_app.c motion_server_app.c MotionAR_Manager.c motionar_server_app.c MotionAW_Manager.c motionaw_server_app.c MotionCP_Manager.c motioncp_server_app.c MotionFX_Manager.c motionfx_server_app.c MotionGR_Manager.c motiongr_server_app.c MotionID_Manager.c motionid_server_app.c MotionPM_Manager.c motionpm_server_app.c p2p_server_app.c
    ../Core/Src/: logger.c ndef_demo.c ndef_dump.c
  group Application/User/STM32_WPAN/Target
    ../STM32_WPAN/Target/: hw_ipcc.c
  group Drivers/BSP/common
    ../../../../../Drivers/BSP/common/firmware/STM/STM32/Src/: spi.c timer.c
  group Drivers/BSP/Components
    ../../../../../Drivers/BSP/Components/hts221/: hts221.c hts221_reg.c
    ../../../../../Drivers/BSP/Components/lis2dw12/: lis2dw12.c lis2dw12_reg.c
    ../../../../../Drivers/BSP/Components/lis2mdl/: lis2mdl.c lis2mdl_reg.c
    ../../../../../Drivers/BSP/Components/lps22hh/: lps22hh.c lps22hh_reg.c
    ../../../../../Drivers/BSP/Components/lsm6dso/: lsm6dso.c lsm6dso_reg.c
    ../../../../../Drivers/BSP/Components/stts751/: stts751.c stts751_reg.c
  group Drivers/BSP/IKS01A3
    ../../../../../Drivers/BSP/IKS01A3/: iks01a3_env_sensors.c iks01a3_env_sensors_ex.c iks01a3_motion_sensors.c iks01a3_motion_sensors_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../../../../../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_cortex.c stm32wbxx_hal_crc.c stm32wbxx_hal_crc_ex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_i2c.c stm32wbxx_hal_i2c_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_rtc.c stm32wbxx_hal_rtc_ex.c stm32wbxx_hal_spi.c stm32wbxx_hal_spi_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Middlewares/NDEF
    ../../../../../Middlewares/ST/ndef/source/message/: ndef_message.c ndef_record.c ndef_type_wifi.c ndef_types.c ndef_types_mime.c ndef_types_rtd.c
    ../../../../../Middlewares/ST/ndef/source/poller/: ndef_poller.c ndef_t2t.c ndef_t3t.c ndef_t4t.c ndef_t5t.c
  group Middlewares/RFAL
    ../../../../../Middlewares/ST/rfal/source/: rfal_analogConfig.c rfal_crc.c rfal_iso15693_2.c rfal_isoDep.c rfal_nfc.c rfal_nfca.c rfal_nfcb.c rfal_nfcDep.c rfal_nfcf.c rfal_nfcv.c rfal_st25tb.c rfal_st25xv.c rfal_t1t.c rfal_t2t.c rfal_t4t.c
    ../../../../../Middlewares/ST/rfal/source/st25r3916/: rfal_rfst25r3916.c
  group Middlewares/ST25R3916
    ../../../../../Middlewares/ST/rfal/source/st25r3916/: st25r3916.c st25r3916_aat.c st25r3916_com.c st25r3916_irq.c st25r3916_led.c
  group Middlewares/STM32_MotionAR_Library
    ../../../../../Middlewares/ST/STM32_MotionAR_Library/Lib/: MotionAR_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionAW_Library
    ../../../../../Middlewares/ST/STM32_MotionAW_Library/Lib/: MotionAW_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionCP_Library
    ../../../../../Middlewares/ST/STM32_MotionCP_Library/Lib/: MotionCP_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionFX_Library
    ../../../../../Middlewares/ST/STM32_MotionFX_Library/Lib/: MotionFX_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionGR_Library
    ../../../../../Middlewares/ST/STM32_MotionGR_Library/Lib/: MotionGR_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionID_Library
    ../../../../../Middlewares/ST/STM32_MotionID_Library/Lib/: MotionID_CM4F_wc32_ot.a
  group Middlewares/STM32_MotionPM_Library
    ../../../../../Middlewares/ST/STM32_MotionPM_Library/Lib/: MotionPM_CM4F_wc32_ot.a
  group Middlewares/STM32_WPAN
    ../../../../../Middlewares/ST/STM32_WPAN/ble/core/auto/: ble_gap_aci.c ble_gatt_aci.c ble_hal_aci.c ble_hci_le.c ble_l2cap_aci.c
    ../../../../../Middlewares/ST/STM32_WPAN/utilities/: dbg_trace.c otp.c stm_list.c stm_queue.c
    ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/tl/: hci_tl.c hci_tl_if.c shci_tl.c shci_tl_if.c tl_mbox.c
    ../../../../../Middlewares/ST/STM32_WPAN/ble/svc/Src/: motenv_stm.c p2p_stm.c svc_ctl.c
    ../../../../../Middlewares/ST/STM32_WPAN/ble/core/template/: osal.c
    ../../../../../Middlewares/ST/STM32_WPAN/interface/patterns/ble_thread/shci/: shci.c
  group Utilities
    ../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../Utilities/sequencer/: stm32_seq.c
